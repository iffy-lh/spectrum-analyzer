# Keil uVision project atk_f103.uvprojx, settings and files
target TFTLCD (6180000::V6.18::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103_original +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: STM32F103xE,ARM_MATH_CM3
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\User;..\..\Drivers\CMSIS\DSP\Include;..\..\Middlewares\USB\Core\Inc;..\..\Middlewares\USB\Class\CDC\Inc;..\..\Middlewares\USB\HAL;..\..\Middlewares\USB\APP;..\..\Middlewares;..\..\Middlewares\MALLOC
  asm include: ;..\..\Middlewares;..\..\Middlewares\MALLOC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c
  group Readme
    ../../: readme.txt
  group Drivers/BSP/ADC
    ../../Drivers/BSP/ADC/: adc.c
  group Drivers/BSP/DMA
    ../../Drivers/BSP/DMA/: dma.c
  group CMSIS/DSP
    ../../Drivers/CMSIS/Lib/ARM/: arm_cortexM3l_math.lib
  group Middlewares/USB/Core
    ../../Middlewares/USB/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/USB/CDC
    ../../Middlewares/USB/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/USB/HAL
    ../../Middlewares/USB/HAL/: stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
  group Middlewares/USB/APP
    ../../Middlewares/USB/APP/: usbd_cdc_interface.c usbd_conf.c usbd_desc.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
